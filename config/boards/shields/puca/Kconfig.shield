## config/boards/shields/puca/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_PUCA
	def_bool $(shields_list_contains,puca)
```
